# Keil uVision project Project.uvprojx, settings and files
target LED Optical Communication (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_hd.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_usart.c stm32f10x_usart.h
  group System
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: LED.c LED.h OLED.c OLED.h OLED_Data.c OLED_Data.h Key.c Key.h OOK.c OOK.h Voice.c Voice.h
  group User
    ./User/: main.c stm32f10x_conf.h
